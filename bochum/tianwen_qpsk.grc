options:
  parameters:
    author: Daniel Estevez
    generate_options: hb
    id: tianwen_qpsk
    output_language: python
    title: Tianwen-1 low rate QPSK decoder
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: cc_decoder
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[109,79]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: cc_decoder2
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[109,79]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: '1020'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, int(np.ceil(11*sps*nfilts)))
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/(decimation*baudrate)
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleave_0_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1j
    type: complex
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"SOB"'
    num_inputs: '4'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"00011010110011111111110000011101"'
    tagname: SOB
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_1_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"00011010110011111111110000011101"'
    tagname: SOB
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_1_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"00011010110011111111110000011101"'
    tagname: SOB
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_1_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"00011010110011111111110000011101"'
    tagname: SOB
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.01'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '128'
    rolloff: alpha
    samps_per_sym: sps*4
    type: cc
    w: '0.001'
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_decoder
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_decoder2
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/8*0.8
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8*0.3
    win: firdes.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: constellation
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: filtered
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: frames
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pdu_utils_tags_to_pdu_X_0
  id: pdu_utils_tags_to_pdu_X
  parameters:
    boost_time: 'False'
    cfg_port: 'False'
    end_tag: EOB
    eob_alignment: '8'
    eob_offset: '0'
    max_pdu_size: frame_len * 8
    prepend: '[]'
    pub_det: 'False'
    rate: baudrate
    start_tag: SOB
    start_time: '0.0'
    tail_size: '0'
    type: b
  states: {}
- name: pdu_utils_tags_to_pdu_X_0_0
  id: pdu_utils_tags_to_pdu_X
  parameters:
    boost_time: 'False'
    cfg_port: 'False'
    end_tag: EOB
    eob_alignment: '8'
    eob_offset: '0'
    max_pdu_size: frame_len * 8
    prepend: '[]'
    pub_det: 'False'
    rate: baudrate
    start_tag: SOB
    start_time: '0.0'
    tail_size: '0'
    type: b
  states: {}
- name: pdu_utils_tags_to_pdu_X_0_0_0
  id: pdu_utils_tags_to_pdu_X
  parameters:
    boost_time: 'False'
    cfg_port: 'False'
    end_tag: EOB
    eob_alignment: '8'
    eob_offset: '0'
    max_pdu_size: frame_len * 8
    prepend: '[]'
    pub_det: 'False'
    rate: baudrate
    start_tag: SOB
    start_time: '0.0'
    tail_size: '0'
    type: b
  states: {}
- name: pdu_utils_tags_to_pdu_X_0_0_0_0
  id: pdu_utils_tags_to_pdu_X
  parameters:
    boost_time: 'False'
    cfg_port: 'False'
    end_tag: EOB
    eob_alignment: '8'
    eob_offset: '0'
    max_pdu_size: frame_len * 8
    prepend: '[]'
    pub_det: 'False'
    rate: baudrate
    start_tag: SOB
    start_time: '0.0'
    tail_size: '0'
    type: b
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: 315e3
  states: {}
- name: satellites_ccsds_descrambler_0
  id: satellites_ccsds_descrambler
  parameters: {}
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_complex_to_float_0_0, '0', blocks_interleave_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_interleave_0_0, '1']
- [blocks_interleave_0, '0', fec_extended_decoder_0, '0']
- [blocks_interleave_0_0, '0', fec_extended_decoder_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_not_xx_0, '0', digital_correlate_access_code_tag_xx_0_1, '0']
- [blocks_not_xx_0_0, '0', digital_correlate_access_code_tag_xx_0_1_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_1, '0', blocks_tag_debug_0, '1']
- [digital_correlate_access_code_tag_xx_0_1, '0', pdu_utils_tags_to_pdu_X_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_1_0, '0', blocks_tag_debug_0, '2']
- [digital_correlate_access_code_tag_xx_0_1_0, '0', pdu_utils_tags_to_pdu_X_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_1_0_0, '0', blocks_tag_debug_0, '3']
- [digital_correlate_access_code_tag_xx_0_1_0_0, '0', pdu_utils_tags_to_pdu_X_0_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_1_1, '0', blocks_tag_debug_0, '0']
- [digital_correlate_access_code_tag_xx_0_1_1, '0', pdu_utils_tags_to_pdu_X_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_complex_to_float_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [digital_costas_loop_cc_0_0, '0', pad_sink_0, '0']
- [digital_fll_band_edge_cc_0, '0', low_pass_filter_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [fec_extended_decoder_0, '0', blocks_not_xx_0, '0']
- [fec_extended_decoder_0, '0', digital_correlate_access_code_tag_xx_0_1_1, '0']
- [fec_extended_decoder_0_0, '0', blocks_not_xx_0_0, '0']
- [fec_extended_decoder_0_0, '0', digital_correlate_access_code_tag_xx_0_1_0, '0']
- [low_pass_filter_0, '0', digital_symbol_sync_xx_0_0, '0']
- [low_pass_filter_0, '0', pad_sink_0_0, '0']
- [pad_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [pdu_utils_tags_to_pdu_X_0, pdu_out, satellites_ccsds_descrambler_0, in]
- [pdu_utils_tags_to_pdu_X_0_0, pdu_out, satellites_ccsds_descrambler_0, in]
- [pdu_utils_tags_to_pdu_X_0_0_0, pdu_out, satellites_ccsds_descrambler_0, in]
- [pdu_utils_tags_to_pdu_X_0_0_0_0, pdu_out, satellites_ccsds_descrambler_0, in]
- [satellites_ccsds_descrambler_0, out, pad_sink_1, in]

metadata:
  file_format: 1
