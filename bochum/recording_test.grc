options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: recording_test
    output_language: python
    title: Tianwen-1 recording test
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,1
    label: Carrier frequency (for low-rate)
    type: real
    value: '-10e3'
  states: {}
- name: costas_bw
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0
    label: QPSK Costas loop bandwidth
    type: real
    value: '0.005'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3124943'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: hsd_long_frames.u8
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: hsd_long_frames.u8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/20200729_224407_3124943HDRcut.raw
    repeat: 'True'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_pdu_to_tagged_stream_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_1_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: carrier_freq
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 0.8*samp_rate/20, 0.3*samp_rate)
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,1
    legend: 'False'
    name: '"QPSK constellation"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,1
    name: '"BPSK constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2,1
    name: '"QPSK low-rate constellation"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0
    label: PSD
    legend: 'False'
    name: Total spectrum
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-60'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate/10
    fc: '0'
    fftsize: '4096'
    gui_hint: 2,0
    label: PSD
    legend: 'False'
    name: QPSK low-rate spectrum
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-60'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate/10
    fc: '0'
    fftsize: '4096'
    gui_hint: 1,0
    label: PSD
    legend: 'False'
    name: Low-rate spectrum
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-60'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: tianwen_hsd_noshort_0
  id: tianwen_hsd_noshort
  parameters:
    pll_bw: costas_bw
    samp_rate: samp_rate
  states: {}
- name: tianwen_lowrate_0
  id: tianwen_lowrate
  parameters:
    samp_rate: samp_rate/10
  states: {}
- name: tianwen_qpsk_0
  id: tianwen_qpsk
  parameters:
    samp_rate: samp_rate/10
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_pdu_to_tagged_stream_1, '0', blocks_file_sink_0, '0']
- [blocks_pdu_to_tagged_stream_1_0, '0', blocks_file_sink_0_0, '0']
- [blocks_throttle_0, '0', satellites_rms_agc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', tianwen_lowrate_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', tianwen_qpsk_0, '0']
- [satellites_rms_agc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [satellites_rms_agc_0, '0', qtgui_freq_sink_x_0, '0']
- [satellites_rms_agc_0, '0', tianwen_hsd_noshort_0, '0']
- [tianwen_hsd_noshort_0, '0', qtgui_const_sink_x_0, '0']
- [tianwen_hsd_noshort_0, long_frames, blocks_pdu_to_tagged_stream_1, pdus]
- [tianwen_lowrate_0, '0', qtgui_const_sink_x_1, '0']
- [tianwen_lowrate_0, '1', qtgui_freq_sink_x_0_0_0, '0']
- [tianwen_lowrate_0, frames, blocks_pdu_to_tagged_stream_1_0, pdus]
- [tianwen_qpsk_0, '0', qtgui_const_sink_x_1_0, '0']
- [tianwen_qpsk_0, '1', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
