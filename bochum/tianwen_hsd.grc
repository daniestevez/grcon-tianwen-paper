options:
  parameters:
    author: Daniel Estevez
    generate_options: hb
    id: tianwen_hsd
    output_language: python
    run: 'False'
    title: Tianwen-1 high-speed data decoder
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: cc_decoder
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: cc_decoder2
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: '1020'
  states: {}
- name: frame_len_short
  id: variable
  parameters:
    value: '252'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, int(np.ceil(11*sps*nfilts)))
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baudrate
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''1ACFFC1D'''
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleave_0_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1j
    type: complex
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0_0_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: digital_additive_scrambler_bb_0_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0xA9'
    reset_tag_key: '"packet_len"'
    seed: '0xFF'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"00011010110011111111110000011101"'
    tagname: SOB
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"00011010110011111111110000011101"'
    tagname: SOB
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_1_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"00011010110011111111110000011101"'
    tagname: SOB
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_1_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"00011010110011111111110000011101"'
    tagname: SOB
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: pll_bw
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {state: disabled}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_decoder
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_decoder2
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {state: disabled}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: constellation
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: long_frames
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: short_frames
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pdu_utils_pack_unpack_0
  id: pdu_utils_pack_unpack
  parameters:
    bit_order: pdu_utils.BIT_ORDER_MSB_FIRST
    mode: pdu_utils.MODE_PACK_BYTE
  states: {}
- name: pdu_utils_pdu_length_filter_1
  id: pdu_utils_pdu_length_filter
  parameters:
    drop_long: 'True'
    length: '1000'
  states: {}
- name: pdu_utils_pdu_length_filter_1_0
  id: pdu_utils_pdu_length_filter
  parameters:
    drop_long: 'False'
    length: '1000'
  states: {}
- name: pdu_utils_tags_to_pdu_X_0
  id: pdu_utils_tags_to_pdu_X
  parameters:
    boost_time: 'False'
    cfg_port: 'False'
    end_tag: EOB
    eob_alignment: '8'
    eob_offset: '0'
    max_pdu_size: frame_len * 8
    prepend: '[]'
    pub_det: 'False'
    rate: baudrate
    start_tag: SOB
    start_time: '0.0'
    tail_size: '0'
    type: b
  states: {}
- name: pdu_utils_tags_to_pdu_X_0_0
  id: pdu_utils_tags_to_pdu_X
  parameters:
    boost_time: 'False'
    cfg_port: 'False'
    end_tag: EOB
    eob_alignment: '8'
    eob_offset: '0'
    max_pdu_size: frame_len * 8
    prepend: '[]'
    pub_det: 'False'
    rate: baudrate
    start_tag: SOB
    start_time: '0.0'
    tail_size: '0'
    type: b
  states: {}
- name: pdu_utils_tags_to_pdu_X_0_0_0
  id: pdu_utils_tags_to_pdu_X
  parameters:
    boost_time: 'False'
    cfg_port: 'False'
    end_tag: EOB
    eob_alignment: '8'
    eob_offset: '0'
    max_pdu_size: frame_len * 8
    prepend: '[]'
    pub_det: 'False'
    rate: baudrate
    start_tag: SOB
    start_time: '0.0'
    tail_size: '0'
    type: b
  states: {}
- name: pdu_utils_tags_to_pdu_X_0_0_0_0
  id: pdu_utils_tags_to_pdu_X
  parameters:
    boost_time: 'False'
    cfg_port: 'False'
    end_tag: EOB
    eob_alignment: '8'
    eob_offset: '0'
    max_pdu_size: frame_len * 8
    prepend: '[]'
    pub_det: 'False'
    rate: baudrate
    start_tag: SOB
    start_time: '0.0'
    tail_size: '0'
    type: b
  states: {}
- name: pll_bw
  id: parameter
  parameters:
    label: Costas loop bandwidth
    value: '0'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 1,1
    label1: 0º/180º phase ambiguity
    label2: 90º/270º phase ambiguity
    name: Syncword correlation
    nconnections: '2'
    size: '50000'
    srate: samp_rate
    tr_chan: '1'
    tr_level: '0.9'
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: 3e6
  states: {}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    basis: '0'
    verbose: 'False'
  states: {}
- name: satellites_decode_rs_interleaved_0
  id: satellites_decode_rs_interleaved
  parameters:
    basis: '0'
    codewords: '4'
    verbose: 'False'
  states: {}

connections:
- [blocks_char_to_float_0, '0', fir_filter_xxx_1, '0']
- [blocks_char_to_float_0_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_complex_to_float_0_0, '0', blocks_interleave_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_interleave_0_0, '1']
- [blocks_interleave_0, '0', fec_extended_decoder_0, '0']
- [blocks_interleave_0_0, '0', fec_extended_decoder_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_not_xx_0, '0', digital_correlate_access_code_tag_xx_0_1, '0']
- [blocks_not_xx_0_0, '0', digital_correlate_access_code_tag_xx_0_1_0_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', digital_additive_scrambler_bb_0_0, '0']
- [blocks_tagged_stream_to_pdu_0_0_0_0_0, pdus, pdu_utils_pack_unpack_0, pdu_in]
- [digital_additive_scrambler_bb_0_0, '0', blocks_tagged_stream_to_pdu_0_0_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', pdu_utils_tags_to_pdu_X_0, '0']
- [digital_correlate_access_code_tag_xx_0_1, '0', pdu_utils_tags_to_pdu_X_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_1_0, '0', pdu_utils_tags_to_pdu_X_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_1_0_0, '0', pdu_utils_tags_to_pdu_X_0_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_complex_to_float_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [digital_costas_loop_cc_0_0, '0', pad_sink_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [fec_extended_decoder_0, '0', blocks_not_xx_0, '0']
- [fec_extended_decoder_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [fec_extended_decoder_0, '0', digital_map_bb_0, '0']
- [fec_extended_decoder_0_0, '0', blocks_not_xx_0_0, '0']
- [fec_extended_decoder_0_0, '0', digital_correlate_access_code_tag_xx_0_1_0, '0']
- [fec_extended_decoder_0_0, '0', digital_map_bb_0_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_1_0, '0']
- [fir_filter_xxx_1_0, '0', qtgui_time_sink_x_1_0, '1']
- [pad_source_0, '0', digital_symbol_sync_xx_0_0, '0']
- [pdu_utils_pack_unpack_0, pdu_out, pdu_utils_pdu_length_filter_1, pdu_in]
- [pdu_utils_pack_unpack_0, pdu_out, pdu_utils_pdu_length_filter_1_0, pdu_in]
- [pdu_utils_pdu_length_filter_1, pdu_out, satellites_decode_rs_0, in]
- [pdu_utils_pdu_length_filter_1_0, pdu_out, satellites_decode_rs_interleaved_0, in]
- [pdu_utils_tags_to_pdu_X_0, pdu_out, blocks_pdu_to_tagged_stream_0, pdus]
- [pdu_utils_tags_to_pdu_X_0_0, pdu_out, blocks_pdu_to_tagged_stream_0, pdus]
- [pdu_utils_tags_to_pdu_X_0_0_0, pdu_out, blocks_pdu_to_tagged_stream_0, pdus]
- [pdu_utils_tags_to_pdu_X_0_0_0_0, pdu_out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_decode_rs_0, out, pad_sink_1_0, in]
- [satellites_decode_rs_interleaved_0, out, pad_sink_1, in]

metadata:
  file_format: 1
